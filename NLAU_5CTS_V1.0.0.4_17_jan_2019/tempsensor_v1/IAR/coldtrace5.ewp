# IAR project coldtrace5.ewp, settings and files
configuration Nexleaf (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5994 MSP430FR5994
  General.GStackSize2: 1500
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: _DEBUG; __MSP430FR5994__; _FISM_; _FDEBUG_; DEBUG; _FMODEM_; _FSPI_
  ICC430.newCCIncludePaths: $SOURCE_DIR$\third_party_libs\driverlib\MSP430FR5xx_6xx; $SOURCE_DIR$\third_party_libs\driverlib\MSP430FR5xx_6xx\deprecated; $SOURCE_DIR$\third_party_libs\minini_12b; $SOURCE_DIR$\third_party_libs\libjson-0.8; $SOURCE_DIR$\src; $SOURCE_DIR$\src\communications; $SOURCE_DIR$\src\system; $SOURCE_DIR$\src\tests; $SOURCE_DIR$\src\thermal; $SOURCE_DIR$\src\utils; $SOURCE_DIR$\third_party_libs\ff11\src; $SOURCE_DIR$\MSPBoot\Util
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430fr5994_app.xcl
  XLINK.XlinkStackSize: 1
configuration EVIN (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  ICC430.CCDefines: _DEBUG; __MSP430FR5969__; _EVIN_BUILD_
  ICC430.newCCIncludePaths: $SOURCE_DIR$\third_party_libs\driverlib\MSP430FR5xx_6xx; $SOURCE_DIR$\third_party_libs\driverlib\MSP430FR5xx_6xx\deprecated; $SOURCE_DIR$\third_party_libs\minini_12b; $SOURCE_DIR$\third_party_libs\libjson-0.8; $SOURCE_DIR$\src; $SOURCE_DIR$\src\communications; $SOURCE_DIR$\src\system; $SOURCE_DIR$\src\tests; $SOURCE_DIR$\src\thermal; $SOURCE_DIR$\src\utils; $SOURCE_DIR$\third_party_libs\ff11\src; $SOURCE_DIR$\MSPBoot\; $SOURCE_DIR$\MSPBoot\Util; $SOURCE_DIR$\MSPBoot\AppMgr; $SOURCE_DIR$\MSPBoot\MI
  XLINK.XclFile: lnk430fr5969_CT5_App.xcl
configuration Fism (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmff.h
  General.GStackSize2: 160
  General.GHeapSize2: 160
  ICC430.CCDefines: _DEBUG; __MSP430FR5994__; _FISM_; _FDEBUG_; _FMODEM_; _FSPI_; _WDT_; _SPI_FLASH_; xxUSING_REALTIME_CLOCK
  group (top)
    ./: lnk430fr5969_CT5_App.xcl lnk430fr5994_app.xcl
    ../MSPBoot/: TI_MSPBoot_Mgr_Vectors.h TI_MSPBoot_Mgr_Vectors_FR57xx.c
  group MSPBoot/AppMgr
    ../MSPBoot/AppMgr/: TI_MSPBoot_VecRed_FR5969.c
  group MSPBoot/Util
    ../MSPBoot/Util/: FatFs_Lib.c
  group src
    ../src/: config.c config_profiles.c
    ../src/thermal/: temperature.c
  group src/communications
    ../src/communications/: apn_config.c apn_config.h data_transmit.c file_system.c file_system.h fridge_data.c fridge_data.h http.c jsonAPIs.c modem.c modem_uart.c ota.c ota.h packet_format.c sms.c sms.h
    ../src/system/: fridge_uart.c
  group src/system
    ../src/system/: battery.c battery.h buzzer.c fatdata.c hardware_buttons.c i2c.c rtc.c spi_flash.c spi_flash.h timer.c watchdog.c
  group src/tests
    ../src/thermal/: debug.c
  group src/thermal
    ../src/thermal/: alarms.c device_alarms.c device_alarms.h events.c globals.c lcd.c main_system.c state_machine.c thermalcanyon.c
  group src/utils
    ../src/utils/: encode.c stringutils.c
  group third_party_libs/driverlib/MSP430FR5xx_6xx
    ../third_party_libs/driverlib/MSP430FR5xx_6xx/: adc12_b.c aes256.c comp_e.c crc.c crc32.c cs.c dma.c esi.c eusci_a_spi.c eusci_a_uart.c eusci_b_i2c.c eusci_b_spi.c framctl.c gpio.c lcd_c.c mpu.c mpy32.c pmm.c ram.c ref_a.c rtc_b.c rtc_c.c sfr.c sysctl.c timer_a.c timer_b.c tlv.c wdt_a.c
  group third_party_libs/libjson-0.8
    ../third_party_libs/libjson-0.8/: json.c
  group third_party_libs/minini_12b
    ../third_party_libs/minini_12b/: minIni.c test.c
