# IAR project ct5_bootloader.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmfn.h
  General.OGChipSelectMenu: MSP430FR5994 MSP430FR5994
  General.GStackSize2: 500
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: _DEBUG; __MSP430FR5994__; MSPBoot_SIMPLE; _CT5_BOOTLOADER_; _FISM_; _FDEBUG_
  ICC430.newCCIncludePaths: $SOURCE_DIR$\MSPBoot; $SOURCE_DIR$\MSPBoot\MI; $SOURCE_DIR$\MSPBoot\Comm; $SOURCE_DIR$\MSPBoot\AppMgr; $SOURCE_DIR$\MSPBoot\Util; $SOURCE_DIR$\third_party_libs\driverlib\MSP430FR5xx_6xx; $SOURCE_DIR$\third_party_libs\driverlib\MSP430FR5xx_6xx\deprecated; $SOURCE_DIR$\third_party_libs\sd_raw; $SOURCE_DIR$\third_party_libs\ff11; $SOURCE_DIR$\third_party_libs\ff11\src; $SOURCE_DIR$\src\system; $SOURCE_DIR$\src\thermal; $SOURCE_DIR$\src\; $SOURCE_DIR$\third_party_libs\driverlib\MSP430FR5xx_6xx
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430fr5994_bootloader.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: lnk430fr5969_CT5_Bootloader.xcl lnk430fr5994_bootloader.xcl
  group MSPBoot
    ../MSPBoot/: cstartup.s43 main.c TestFWtxt.c TestFWtxt.h TI_MSPBoot_Common.h TI_MSPBoot_Config.h
  group MSPBoot/AppMgr
    ../MSPBoot/AppMgr/: Crc.c Crc.h TI_MSPBoot_AppMgr.c TI_MSPBoot_AppMgr.h TI_MSPBoot_VecRed_FR5969.c
  group MSPBoot/MI
    ../MSPBoot/MI/: TI_MSPBoot_MI.h TI_MSPBoot_MI_FRAM.c
  group MSPBoot/Util
    ../MSPBoot/Util/: FAT_Update.c FAT_Update.h FatFs_Lib.c FatFs_Lib.h TI_TXT_File_Parser.c TI_TXT_File_Parser.h
  group src/system
    ../src/system/: battery.c i2c.c image_write.c image_write.h spi_flash.c timer.c
  group src/thermal
    ../src/thermal/: debug.c lcd.c
  group third_party_libs/driverlib/MSP430FR5xx_6xx
    ../third_party_libs/driverlib/MSP430FR5xx_6xx/: cs.c
  group third_party_libs/ff11/src
    ../third_party_libs/ff11/src/: diskio.c ff.c
  group third_party_libs/sd_raw
    ../third_party_libs/sd_raw/: sd_raw.c
