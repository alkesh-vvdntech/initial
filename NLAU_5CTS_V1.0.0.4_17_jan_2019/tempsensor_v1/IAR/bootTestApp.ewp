# IAR project bootTestApp.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430FR5969__
  ICC430.newCCIncludePaths: $SOURCE_DIR$\MSPBoot\Util; $SOURCE_DIR$\third_party_libs\ff11\src
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: C:\NexLeaf\coldtrace5\tempsensor_v1\IAR\lnk430fr5969_CT5_App.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: lnk430fr5969_CT5_App.xcl
    ../MSPBoot/: test_main.c
  group MSPBoot/Util
    ../MSPBoot/Util/: FatFs_Lib.c
